File: eduIO/eduIO.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Moving to v9
Other:
- note removed: "4"
- note removed: "PowerPage"
